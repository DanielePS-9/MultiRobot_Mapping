Commit message: bridge

File: ros_ws/src/turtlebot3_gazebo/turtlebot3_gazebo/urdf/turtlebot3_waffle.urdf (robot description, URDF)
Before this commit: robot turtlebot3_waffle, 12 links, 11 joints
Links:
- link camera_link: mass None -> 0.564
